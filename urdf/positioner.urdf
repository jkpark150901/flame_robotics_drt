Commit message: mujoco

File: urdf/positioner.urdf (robot description, URDF)
Before this commit: robot positioner, 7 links, 6 joints
Joints:
- joint f_column_z_to_f_column_r: origin xyz=0.48 1.37 1.3 rpy=0 0 0 -> xyz=0.48 1.37 0.629 rpy=0 0 0
